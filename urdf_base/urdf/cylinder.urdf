Commit message: urdf

File: urdf_base/urdf/cylinder.urdf (robot description, URDF)
Before this commit: robot first, 2 links, 0 joints
Links:
- removed link right_wheel
